# Keil uVision project BasicUI.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC5)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: BasicUI
  c flags: Optim=1 wLevel=2
  c include: .\drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group drivers
    ./drivers/: adc.c comparator.c dac.c gpio.c i2c.c timer.c uart.c adc.h comparator.h dac.h gpio.h i2c.h platform.h timer.h uart.h leds.c leds.h switches.c switches.h delay.c delay.h eeprom.c eeprom.h lpc_types.h
  group src
    ./src/: complex_g3.c complex_g3.h main.c reader.c reader.h errorm.c errorm.h decoder.h decoder.c fft.c fft.h decoder_gtzl.c decoder_gtzl.h gtzl.c gtzl.h lcd.c lcd.h eeprom_g3.c eeprom_g3.h algorithm_setter.c algorithm_setter.h frequencies_comparator.c frequencies_comparator.h global_parameters.h mask_calibrate.c mask_calibrate.h scroll_lcd.c scroll_lcd.h
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
